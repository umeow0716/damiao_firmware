# Keil uVision project usart_uart_dma.uvprojx, settings and files
target usart_uart_dma_Debug (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F448MCTI HDSC
  pack: HDSC.HC32F448.1.1.0
  cpu: IROM1(0x00000000,0x40000) IROM2(0x03000C00,0x400) IRAM1(0x1FFF8000,0x10000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: usart_uart_dma +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __DEBUG,HC32F448,USE_DDL_DRIVER,
  c include: ../source;../../../../../../drivers/cmsis/Device/HDSC/hc32f4xx/Include;../../../../../../drivers/cmsis/Include;../../../../../../drivers/hc32_ll_driver/inc;../../../../../../drivers/bsp/components/tca9539;../../../../../../drivers/bsp/ev_hc32f448_lqfp80;../../../../../../midwares/hc32/ring_buffer;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x03000C00 size 0x400
  memory RVCT9: RAM 0x1FFF8000 size 0x10000
  memory RVCT10: RAM 0x200F0000 size 0x1000
  scatter file: .\config\linker\HC32F448xC.sct
  link misc: --keep=*Handler
  group cmsis
    ./: startup_hc32f448.s
    ../../../../../../drivers/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f448.c
  group source
    ../source/: main.c uart.c
  group driver
    ../../../../../../drivers/hc32_ll_driver/src/: hc32_ll.c hc32_ll_aos.c hc32_ll_clk.c hc32_ll_dma.c hc32_ll_efm.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_gpio.c hc32_ll_i2c.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_keyscan.c hc32_ll_pwc.c hc32_ll_tmr0.c hc32_ll_usart.c hc32_ll_utility.c
  group tca9539
    ../../../../../../drivers/bsp/components/tca9539/: tca9539.c
  group ev_hc32f448_lqfp80
    ../../../../../../drivers/bsp/ev_hc32f448_lqfp80/: ev_hc32f448_lqfp80.c ev_hc32f448_lqfp80_tca9539.c
  group ring_buffer
    ../../../../../../midwares/hc32/ring_buffer/: ring_buf.c
  group Readme
    ../: Readme.txt
target usart_uart_dma_Release (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F448MCTI HDSC
  pack: HDSC.HC32F448.1.1.0
  cpu: as above
  output: usart_uart_dma +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: HC32F448,USE_DDL_DRIVER,
  c include: ..\source;../../../../../../drivers/cmsis/Device/HDSC/hc32f4xx/Include;../../../../../../drivers/cmsis/Include;../../../../../../drivers/hc32_ll_driver/inc;../../../../../../drivers/bsp/components/tca9539;../../../../../../drivers/bsp/ev_hc32f448_lqfp80;../../../../../../midwares/hc32/ring_buffer;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x03000C00 size 0x400
  memory RVCT9: RAM 0x1FFF8000 size 0x10000
  memory RVCT10: RAM 0x200F0000 size 0x1000
  scatter file: .\config\linker\HC32F448xC.sct
  link misc: --keep=*Handler
