<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\timera_hard_trigger.ewp</path>
  </project>
  <batchBuild/>
</workspace>


