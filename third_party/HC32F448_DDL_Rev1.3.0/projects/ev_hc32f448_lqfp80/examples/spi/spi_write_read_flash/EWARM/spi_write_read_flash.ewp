# IAR project spi_write_read_flash.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: Default    None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; HC32F448; USE_DDL_DRIVER
  ICCARM.CCIncludePath2: ../source; ../../../../../../drivers/cmsis/Device/HDSC/hc32f4xx/Include; ../../../../../../drivers/cmsis/Include; ../../../../../../drivers/hc32_ll_driver/inc; ../../../../../../drivers/bsp/components/tca9539; ../../../../../../drivers/bsp/components/w25qxx; ../../../../../../drivers/bsp/ev_hc32f448_lqfp80
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: spi_write_read_flash.hex
  ILINK.IlinkOutputFile: spi_write_read_flash.out
  ILINK.IlinkConfigDefines: _LINK_FLASH_= 0; _HC32F448_256K_= 1
  ILINK.IlinkIcfFile: config/linker/HC32F448.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HC32F448; USE_DDL_DRIVER
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group (top)
    ../: Readme.txt
  group cmsis
    ../../../../../../drivers/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f448.c
    ./: startup_hc32f448.s
  group driver
    ../../../../../../drivers/hc32_ll_driver/src/: hc32_ll.c hc32_ll_clk.c hc32_ll_efm.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_gpio.c hc32_ll_i2c.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_keyscan.c hc32_ll_pwc.c hc32_ll_spi.c hc32_ll_utility.c
  group bsp/components/tca9539
    ../../../../../../drivers/bsp/components/tca9539/: tca9539.c
  group bsp/components/w25qxx
    ../../../../../../drivers/bsp/components/w25qxx/: w25qxx.c
  group bsp/ev_hc32f448_lqfp80
    ../../../../../../drivers/bsp/ev_hc32f448_lqfp80/: ev_hc32f448_lqfp80.c ev_hc32f448_lqfp80_tca9539.c ev_hc32f448_lqfp80_w25qxx.c
  group source
    ../source/: main.c
