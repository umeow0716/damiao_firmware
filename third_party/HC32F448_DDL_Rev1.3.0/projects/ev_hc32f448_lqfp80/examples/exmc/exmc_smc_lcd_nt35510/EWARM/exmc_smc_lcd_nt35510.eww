<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\exmc_smc_lcd_nt35510.ewp</path>
  </project>
  <batchBuild/>
</workspace>


