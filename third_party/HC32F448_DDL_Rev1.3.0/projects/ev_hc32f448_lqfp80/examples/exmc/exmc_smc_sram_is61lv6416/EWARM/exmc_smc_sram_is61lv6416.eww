<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\exmc_smc_sram_is61lv6416.ewp</path>
  </project>
  <batchBuild/>
</workspace>


